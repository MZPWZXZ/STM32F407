# Keil uVision project FreeRTOS.uvprojx, settings and files
target 407 (5060960::V5.06 update 7 (build 960)::.\ARMComplier_5.06)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\Driver;..\Driver\Start;..\Driver\Libraries\CMSIS;..\Driver\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Driver\Hardware;..\Driver\Peripherals;..\Driver\Lwip\src\include;..\Driver\Lwip\app;..\Driver\Lwip\arch;..\Driver\Lwip;..\Driver\System;..\Driver\Libraries\STM32F4x7_ETH_Driver\inc;..\Driver\FreeRTOS\Source\include;..\Driver\FreeRTOS\Source\portable\MemMang;..\Driver\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Driver\FreeModbus;..\Driver\FreeModbus\include;..\Driver\FreeModbus\rtu;..\Driver\FreeModbus\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group System
    ../Driver/System/: malloc.c delay.c
  group Hardware
    ../Driver/Hardware/: led.c soft_i2c.c eerom.c 485.c ex_flash.c phy.c
  group Peripherals
    ../Driver/Peripherals/: can.c eth.c timer.c usart.c usb.c
  group FreeModbus
    ../Driver/FreeModbus/: mb.c modbus.c
  group FreeModbus/port
    ../Driver/FreeModbus/port/: mbport.c portevent.c portserial.c porttimer.c
  group FreeModbus/rtu
    ../Driver/FreeModbus/rtu/: mbcrc.c mbrtu.c
  group FreeModbus/ascii
    ../Driver/FreeModbus/ascii/: mbascii.c
  group FreeModbus/include
    ../Driver/FreeModbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group FreeModbus/functions
    ../Driver/FreeModbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Lwip/app
    ../Driver/Lwip/app/: lwip_comm.c ethernetif.c
  group Lwip/arch
    ../Driver/Lwip/arch/: cc.h cpu.h lwipopts.h perf.c sys_arch.c
  group Lwip/netif
    ../Driver/Lwip/src/netif/: ethernet.c
  group Lwip/api
    ../Driver/Lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/core
    ../Driver/Lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Driver/Lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group FreeRTOS/app
    ../Driver/FreeRTOS/Source/include/: FreeRTOSConfig.h FreeRTOS.h
  group FreeRTOS/port
    ../Driver/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Driver/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/src
    ../Driver/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Libraries
    ../Driver/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Driver/Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../Driver/Libraries/CMSIS/: system_stm32f4xx.h system_stm32f4xx.c
  group Start
    ../Driver/Start/: startup_stm32f40_41xxx.s
